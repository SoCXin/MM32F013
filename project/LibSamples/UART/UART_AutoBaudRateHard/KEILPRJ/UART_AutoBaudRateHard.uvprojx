# Keil uVision project UART_AutoBaudRateHard.uvprojx, settings and files
target MM32Series (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MM32F0133C7P MindMotion
  pack: MindMotion.MM32F0130_DFP.1.0.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\Device\MM32F013x\Include;..\..\..\..\..\Device\MM32F013x\HAL_Lib\Inc;..\..\..\..\..\Device\CMSIS\KEIL_Core;..Soft\USER;..Soft\SYSTEM\SYS;..Soft\SYSTEM\DELAY;..Soft\HARDWARE\UART;..Soft\HARDWARE\LED;..\USER;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\HARDWARE\UART;..\HARDWARE\LED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../../../../Device/MM32F013x/Source/: system_mm32f013x.c
    ../../../../../Device/MM32F013x/Source/KEIL_StartAsm/: startup_mm32f013x_keil.s
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/UART/: uart_autobaud.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
  group USER
    ../USER/: main.c
  group HAL_Lib
    ../../../../../Device/MM32F013x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
