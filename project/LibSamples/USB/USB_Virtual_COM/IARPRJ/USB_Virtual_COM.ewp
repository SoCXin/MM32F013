# IAR project USB_Virtual_COM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F0133C7P MindMotion MM32F0133C7P
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: MM32F0133C7P; USE_IAR; _DLIB_FILE_DESCRIPTOR; __ALIGNED
  ICCARM.CCDiagSuppress: Pa082,Pa089
  ICCARM.CCIncludePath2: ..\..\..\..\..\Device\CMSIS\IAR_Core; ..\..\..\..\..\Device\MM32F013x\HAL_Lib\Inc; ..\..\..\..\..\Device\MM32F013x\Include; ..\HARDWARE\LED; ..\HARDWARE\UART_NVIC; ..\SYSTEM\DELAY; ..\SYSTEM\SYS; ..\SYSTEM\UART; ..\USB_lib\inc; ..\USB_User\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ADC_Awdg.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group STARTUP
    ../../../../../Device/MM32F013x/Source/IAR_StartAsm/: startup_mm32f013x_iar.s
    ../../../../../Device/MM32F013x/Source/: system_mm32f013x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/UART_NVIC/: uart_nvic.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
  group USB_lib
    ../USB_lib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group USB_User
    ../USB_User/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USER
    ../USER/: main.c mm32l0xx_it.c
  group HALlib
    ../../../../../Device/MM32F013x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
